## softcpu/qemu/Kconfig.snippet
```kconfig
# Append to QEMU hw/misc/Kconfig
config BIL_SOFTCPU
    bool
    default y
    depends on ARM
```
